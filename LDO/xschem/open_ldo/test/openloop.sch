** sch_path: LDO/xschem/open_ldo/test/openloop.sch


* Circuit Parameters
.param iref = 10u
.param vdd  = 5
.param vss  = 0.0
.param vcm  = 1.25
.param vac  = 60m
.param w857 = 5u
.param l857 = 1u
.param m857 = 1
.param wpar = 10u
.param lpar = 1u
.param mpar = 1
.param w34  = 10u
.param l34  = 1u
.param m34  = 1
.param w6   = 100u
.param l6   = 1u
.param m6   = 1

.param m5   = 1
.param m7   = 5

* OP Parameters & Signals to save
.save all

*Simulation
.control
  set color0 = white

  ac dec 100 1 10G
  setplot ac1
  meas ac GBW when vdb(vout)=0
  meas ac DCG find vdb(vout) at=1
  meas ac PM find vp(vout) when vdb(vout)=0
  print PM*180/PI
  meas ac GM find vdb(vout) when vp(vout)=0
  plot vdb(vout) {vp(vout)*180/PI}
  write tb_opamp_openloop_ac1.raw

  reset
  op
  setplot op1
  unset filetype
  write tb_opamp_openloop.raw

print @m.x1.xm8.m0[vgs]-@m.x1.xm8.m0[vth]
print @m.x1.xm8.m0[vds]
print @m.x1.xm8.m0[id]
print **************
print @m.x1.xm7.m0[vgs]-@m.x1.xm7.m0[vth]
print @m.x1.xm7.m0[vds]
print @m.x1.xm7.m0[id]
print **************
print @m.x1.xm6.m0[vgs]-@m.x1.xm6.m0[vth]
print @m.x1.xm6.m0[vds]
print @m.x1.xm6.m0[gm]
print @m.x1.xm6.m0[gm]/@m.x1.xm6.m0[id]
print **************
print @m.x1.xm5.m0[vgs]-@m.x1.xm5.m0[vth]
print @m.x1.xm5.m0[vds]
print @m.x1.xm5.m0[id]
print **************
print @m.x1.xm1.m0[vgs]-@m.x1.xm1.m0[vth]
print @m.x1.xm1.m0[vds]
print @m.x1.xm1.m0[id]
print @m.x1.xm1.m0[gm]
print @m.x1.xm1.m0[gm]/@m.x1.xm1.m0[id]
print **************
print @m.x1.xm2.m0[vgs]-@m.x1.xm2.m0[vth]
print @m.x1.xm2.m0[vds]
print @m.x1.xm2.m0[id]
print @m.x1.xm2.m0[gm]
print @m.x1.xm2.m0[gm]/@m.x1.xm2.m0[id]
print **************
print @m.x1.xm3.m0[vgs]-@m.x1.xm3.m0[vth]
print @m.x1.xm3.m0[vds]
print @m.x1.xm3.m0[id]
print **************
print @m.x1.xm4.m0[vgs]-@m.x1.xm4.m0[vth]
print @m.x1.xm4.m0[vds]
print @m.x1.xm4.m0[id]

print v(vout)
print v(vin)

.endc

.end



.include $env(PDK_ROOT)/$env(PDK)/libs.tech/ngspice/design.ngspice
.lib $env(PDK_ROOT)/$env(PDK)/libs.tech/ngspice/sm141064.ngspice typical
.lib $env(PDK_ROOT)/$env(PDK)/libs.tech/ngspice/sm141064.ngspice mimcap_statistical
.lib $env(PDK_ROOT)/$env(PDK)/libs.tech/ngspice/sm141064.ngspice cap_mim
.lib $env(PDK_ROOT)/$env(PDK)/libs.tech/ngspice/sm141064.ngspice res_typical

**.subckt openloop
I0 vdd iref DC {iref}
V1 net3 vcm sin(0 {vac} 1Meg) dc 0 ac 1
C1 vout vss 1p m=1
V2 vdd vss DC {vdd}
R2 vin net1 1G m=1
R3 net1 vcm 500 m=1
V3 vcm vss DC {vcm}
R4 net1 net2 5k m=1
C3 vin net3 1 m=1
V4 vss GND DC {vss}
V5 vout net2 1.75
**** begin user architecture code



.include ../../../spice/ota_pex.spice

*** writing format= xdevice vin_n vin_p vdd iref vss vout ota_*

*** for using this SPICE extracted netlists, you may change spice_ignore
*** value to 1 in the OTA symbol (this way you will bypass the prelayout OTA)

*** for parasitic extraction simulation

x1 vin vcm vdd iref vss vout ota_pex


**** end user architecture code
**.ends
.GLOBAL GND
.end
