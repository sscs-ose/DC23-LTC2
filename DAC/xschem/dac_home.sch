v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
T {to Define is to Limit!
     -Oscar Wilde-} 1030 -70 0 0 0.5 0.5 {layer=6
hcenter=true
vcenter=true
weight=bold}
T {2023 PICO Open-Source Chipathon} 590 -560 0 0 1 1 {hcenter=true
vcenter=true
weight=bold}
T {Team.Korea(JunBeom Park)} 510 -440 0 0 0.8 0.8 {font="Nimbus Mono"}
T {Digital-to-Analog Converter in LTC2} 590 -490 0 0 0.8 0.8 {hcenter=true
vcenter=true
layer=11}
T {#technology=GlobalFoundries GF180MCU
#supply voltage=3.3V

#6MSB + 4LSB segmented current-steering DAC
#reference current source = 2uA

#nominal current
<4LSB, binary coded>
1x=10uA, 2x=20uA, 4x=40uA, 8x=80uA

<6MSB, thermometer coded>
16x=160uA} 80 -370 0 0 0.4 0.4 {}
C {devices/title.sym} 160 0 0 0 {name=l1 author="JunBeom Park"}
