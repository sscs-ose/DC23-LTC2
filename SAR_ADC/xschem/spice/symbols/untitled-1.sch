v {xschem version=3.1.0 file_version=1.2
}
G {}
K {}
V {}
S {type=subcircuit
format="@name @pinlist @symname"
template="name=X1"}
E {}
L 4 190 -230 210 -230 {}
L 4 210 -230 230 -240 {}
L 4 230 -230 250 -230 {}
L 4 200 -250 240 -250 {}
L 4 240 -250 240 -210 {}
L 4 200 -210 240 -210 {}
L 4 200 -250 200 -210 {}
L 4 220 -270 220 -250 {}
L 4 200 -210 200 -200 {}
L 4 240 -210 240 -200 {}
B 5 217.5 -272.5 222.5 -267.5 {name=clk
dir=inout}
B 5 187.5 -232.5 192.5 -227.5 {name=vi
dir=inout}
B 5 247.5 -232.5 252.5 -227.5 {name=vo
dir=inout}
B 5 197.5 -202.5 202.5 -197.5 {name=V
dir=inout}
B 5 237.5 -202.5 242.5 -197.5 {name=GND
dir=inout}
