v {xschem version=3.4.4 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
N 80 -160 80 -140 {
lab=#net1}
N -70 -160 -70 -130 {
lab=#net1}
N 50 -100 60 -100 {
lab=#net2}
N 210 -160 210 -140 {
lab=#net1}
N 340 -160 340 -140 {
lab=#net1}
N 470 -160 470 -140 {
lab=#net1}
N 600 -160 600 -140 {
lab=#net1}
N 730 -160 730 -140 {
lab=#net1}
N 910 -160 910 -140 {
lab=xd}
N 1040 -160 1040 -140 {
lab=xd}
N 1170 -160 1170 -140 {
lab=xd}
N 1300 -160 1300 -140 {
lab=xd}
N 1430 -160 1430 -140 {
lab=xd}
N 1560 -160 1560 -140 {
lab=xd}
N 80 -70 80 -40 {
lab=vin}
N 210 -70 210 -50 {
lab=vin}
N 80 -40 80 -20 {
lab=vin}
N 230 -70 230 -30 {
lab=gnd}
N 1560 -70 1560 -50 {
lab=vin}
N 1430 -70 1430 -50 {
lab=vin}
N 1300 -70 1300 -50 {
lab=vin}
N 1170 -70 1170 -50 {
lab=vin}
N 1040 -70 1040 -50 {
lab=vin}
N 910 -70 910 -50 {
lab=vin}
N 730 -70 730 -50 {
lab=vin}
N 600 -70 600 -50 {
lab=vin}
N 470 -70 470 -50 {
lab=vin}
N 340 -70 340 -50 {
lab=vin}
N 1580 -70 1580 -30 {
lab=gnd}
N 1450 -70 1450 -30 {
lab=gnd}
N 1320 -70 1320 -30 {
lab=gnd}
N 1190 -70 1190 -30 {
lab=gnd}
N 1060 -70 1060 -30 {
lab=gnd}
N 930 -70 930 -30 {
lab=gnd}
N 750 -70 750 -30 {
lab=gnd}
N 620 -70 620 -30 {
lab=gnd}
N 490 -70 490 -30 {
lab=gnd}
N 360 -70 360 -30 {
lab=gnd}
N -70 -70 -70 -20 {
lab=gnd}
N -70 -30 1580 -30 {
lab=gnd}
N 730 -210 730 -160 {
lab=#net1}
N 730 -210 790 -210 {
lab=#net1}
N 850 -210 910 -210 {
lab=xd}
N 910 -210 910 -160 {
lab=xd}
N -90 -160 -70 -160 {
lab=#net1}
N 80 -50 1560 -50 {
lab=vin}
N 100 -70 100 -30 {
lab=gnd}
N -90 -160 730 -160 {
lab=#net1}
N -120 -160 -90 -160 {
lab=#net1}
N 1040 -160 1560 -160 {
lab=xd}
N 910 -160 1050 -160 {
lab=xd}
N 1290 -220 1290 -160 {
lab=xd}
N 1290 -230 1290 -210 {
lab=xd}
N 1290 -230 1330 -230 {
lab=xd}
N 50 -70 50 70 {
lab=vin}
N 180 -70 180 20 {
lab=vin}
N 310 -70 310 20 {
lab=vin}
N 440 -70 440 20 {
lab=vin}
N 570 -70 570 20 {
lab=vin}
N 700 -70 700 20 {
lab=vin}
N 880 -70 880 30 {
lab=vin}
N 1010 -70 1010 30 {
lab=vin}
N 1140 -70 1140 30 {
lab=vin}
N 1270 -70 1270 30 {
lab=vin}
N 1400 -70 1400 30 {
lab=vin}
N 1530 -70 1530 30 {
lab=vin}
N 50 30 1530 30 {
lab=vin}
N 570 20 570 30 {
lab=vin}
N 700 20 700 30 {
lab=vin}
N 440 20 440 30 {
lab=vin}
N 310 20 310 30 {
lab=vin}
N 180 20 180 30 {
lab=vin}
N 20 -270 20 -100 {
lab=sample}
N 20 -270 620 -270 {
lab=sample}
N 150 -270 150 -100 {
lab=sample}
N 280 -270 280 -100 {
lab=sample}
N 410 -270 410 -100 {
lab=sample}
N 540 -270 540 -100 {
lab=sample}
N 670 -270 670 -100 {
lab=sample}
N 1500 -260 1500 -100 {
lab=sample}
N 1500 -280 1500 -260 {
lab=sample}
N 620 -270 1500 -270 {
lab=sample}
N 1240 -270 1240 -100 {
lab=sample}
N 980 -270 980 -100 {
lab=sample}
N 1110 -270 1110 -100 {
lab=sample}
N 1370 -270 1370 -100 {
lab=sample}
N 130 -70 130 80 {
lab=gnd}
N 1610 -80 1610 90 {
lab=gnd}
N 130 90 1610 90 {
lab=gnd}
N 130 80 130 90 {
lab=gnd}
N 260 -70 260 90 {
lab=gnd}
N 390 -70 390 90 {
lab=gnd}
N 520 -70 520 90 {
lab=gnd}
N 650 -70 650 90 {
lab=gnd}
N 780 -70 780 90 {
lab=gnd}
N 960 -70 960 90 {
lab=gnd}
N 1480 -70 1480 90 {
lab=gnd}
N 1350 -70 1350 90 {
lab=gnd}
N 1220 -70 1220 90 {
lab=gnd}
N 1090 -70 1090 90 {
lab=gnd}
C {cdac_line_2.sym} 80 -90 0 0 {name=x1
CW=\{sqrt(2)*cu\}
CL=\{sqrt(2)*cu\}}
C {cdac_line_2.sym} 210 -90 0 0 {name=x2
CW=\{sqrt(3)*cu\}
CL=\{sqrt(3)*cu\}}
C {cdac_line_2.sym} 340 -90 0 0 {name=x3
CW=\{sqrt(4)*cu\}
CL=\{sqrt(4)*cu\}}
C {cdac_line_2.sym} 470 -90 0 0 {name=x4
CW=\{sqrt(8)*cu\}
CL=\{sqrt(8)*cu\}}
C {cdac_line_2.sym} 600 -90 0 0 {name=x5
CW=\{sqrt(16)*cu\}
CL=\{sqrt(16)*cu\}}
C {cdac_line_2.sym} 730 -90 0 0 {name=x6
CW=\{sqrt(32)*cu\}
CL=\{sqrt(32)*cu\}}
C {symbols/cap_mim_2f0fF.sym} 820 -210 1 0 {name=CA
W=\{cu\}
L=\{cu\}
model=cap_mim_2f0fF
m=1}
C {cdac_line_2.sym} 910 -90 0 0 {name=x7
CW=\{sqrt(1)*cu\}
CL=\{sqrt(1)*cu\}}
C {cdac_line_2.sym} 1040 -90 0 0 {name=x8
CW=\{sqrt(2)*cu\}
CL=\{sqrt(2)*cu\}}
C {cdac_line_2.sym} 1170 -90 0 0 {name=x9
CW=\{sqrt(4)*cu\}
CL=\{sqrt(4)*cu\}}
C {cdac_line_2.sym} 1300 -90 0 0 {name=x10
CW=\{sqrt(8)*cu\}
CL=\{sqrt(8)*cu\}}
C {cdac_line_2.sym} 1430 -90 0 0 {name=x11
CW=\{sqrt(16)*cu\}
CL=\{sqrt(16)*cu\}}
C {cdac_line_2.sym} 1560 -90 0 0 {name=x12
CW=\{sqrt(32)*cu\}
CL=\{sqrt(32)*cu\}}
C {devices/ipin.sym} 120 -100 1 0 {name=p1 lab=d[0]}
C {devices/ipin.sym} 250 -100 1 0 {name=p2 lab=d[1]}
C {devices/ipin.sym} 380 -100 1 0 {name=p3 lab=d[2]}
C {devices/ipin.sym} 510 -100 1 0 {name=p4 lab=d[3]}
C {devices/ipin.sym} 640 -100 1 0 {name=p5 lab=d[4]}
C {devices/ipin.sym} 770 -100 1 0 {name=p6 lab=d[5]}
C {devices/ipin.sym} 950 -100 1 0 {name=p7 lab=d[6]}
C {devices/ipin.sym} 1080 -100 1 0 {name=p8 lab=d[7]}
C {devices/ipin.sym} 1210 -100 1 0 {name=p9 lab=d[8]}
C {devices/ipin.sym} 1340 -100 1 0 {name=p10 lab=d[9]}
C {devices/ipin.sym} 1470 -100 1 0 {name=p11 lab=d[10]}
C {devices/ipin.sym} 1600 -100 1 0 {name=p12 lab=d[11]}
C {devices/iopin.sym} 80 -20 3 1 {name=p13 lab=vin}
C {devices/iopin.sym} -70 -30 1 0 {name=p14 lab=gnd}
C {symbols/cap_mim_2f0fF.sym} -70 -100 0 0 {name=C1
W=\{cu\}
L=\{cu\}
model=cap_mim_2f0fF
spiceprefix=X
m=1}
C {devices/iopin.sym} 1330 -230 0 0 {name=p16 lab=xd}
C {devices/iopin.sym} 50 70 1 0 {name=p17 lab=vref}
C {devices/iopin.sym} 140 90 1 0 {name=p18 lab=vdd}
C {devices/iopin.sym} 20 -240 0 0 {name=p19 lab=sample}
