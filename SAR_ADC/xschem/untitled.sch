v {xschem version=3.4.4 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {/home/designer/.volare/sky130A/libs.tech/xschem/sky130_stdcells/inv_8.sym} 120 -40 0 0 {name=x1 VGND=VGND VNB=VNB VPB=VPB VPWR=VPWR prefix=sky130_fd_sc_hd__ }
C {/home/designer/.volare/sky130A/libs.tech/xschem/sky130_stdcells/nor2_8.sym} 120 50 0 0 {name=x2 VGND=VGND VNB=VNB VPB=VPB VPWR=VPWR prefix=sky130_fd_sc_hd__ }
C {/home/designer/.volare/sky130A/libs.tech/xschem/sky130_stdcells/xor2_1.sym} 120 -120 0 0 {name=x3 VGND=VGND VNB=VNB VPB=VPB VPWR=VPWR prefix=sky130_fd_sc_hd__ }
C {/home/designer/.volare/sky130A/libs.tech/xschem/sky130_stdcells/and2_1.sym} 290 -120 0 0 {name=x4 VGND=VGND VNB=VNB VPB=VPB VPWR=VPWR prefix=sky130_fd_sc_hd__ }
